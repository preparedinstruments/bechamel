# Repository preparedinstruments/bechamel (continued)

## EAGLE design PCB/Eagle/bechamel.brd

Board: 2 copper layers, 79.5 x 80.3 mm, 117 parts (10 on the bottom side), 119 nets.

Parts:
C1, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C18, C21, C22, C25, C26, C27: 0.1uF; C0805
C3, C4, C5, C16, C23: 10uF; C0805
C17: 5.6nF; C0805
D1: 250mA/100V; SOD-323
FUSE: FUSE; R0805
H1, H5, H6: MOUNT-PAD-ROUND2.8; 2,8-PAD
IC1: TLV73333PDBVT; SOT95P280X145-5N
IC2: ICE40HX1K-TQ144; QFP50P2200X2200X160-144N
IC3: TLV73312PDBVT; SOT95P280X145-5N
IC4: N25Q032A13ESC40F; SOIC127P600X175-8N
IC6: IS62WV2568BLL-55HLI; SOP50P1340X125-32N
J2: SS-53000-001; SS53000001
J3: DM3CS-SF; DM3CSSF
JP1: 2X20
LED6, LED12, LED13: CHIPLED_0805
P-FET2: SOT23-WIDE
PAD1, PAD2, PAD3: SMD1,27-2,54
R1, R17, R25: 470R; R0805
R2, R5, R7, R15, R18, R22, R24, R26, R47, R49, R51, R53: 1K; R0805
R3, R4, R6, R8, R9, R10, R11, R12, R13, R21, R23, R45, R46, R48, R50, R52, R54, R55, R58, R59: 10K; R0805
R14, R36, R37: 100 ohm; R0805
R16, R20, R27: 1.8K; R0805
R19: 300 ohm; R0805
R28, R29, R31, R32, R34, R35, R39, R40: 270R; R0805
R30, R33, R38, R41: 120R; R0805
R42: 1M; R0805
R43, R44: 5k1; R0805
R56: 1K8 ohm; R0805
R57: 180 ohm; R0805
S1, S2, S3, S4, S5, S6, S7, S8, S13: MX1A-11NW; MX1A11NW
S9: 219-06J; CTS-219-06J
SJ2: SJ
U$1: DB15
U$2: USBC-6P; USCX-06FX-XXMX-01
VR1: RV100F-30-4K1B-B10K-B301; RV100F304K1BB10KB301
Y2: ECS-3953M-080-BN-T-TR; ECS3953M080BNTTR

Connections:
1.2V: C4.1, C26.1, C27.1, IC2.27, IC2.51, IC2.92, IC2.111, IC3.5, R14.2
3.3V: C12.1, C15.1, C16.2, C18.1, C21.1, C25.1, D1.A, IC1.5, IC2.6, IC2.30, IC2.46, IC2.57, IC2.72, IC2.89, IC2.100, IC2.123, IC2.133, IC4.8, J3.4, JP1.1, R3.2, R4.2, R6.2, R8.2, R9.2, R10.2, R11.2, R12.2, R13.2, R21.2, R23.2, R45.2, R46.2, R48.2, R50.2, R52.2, R54.2, R55.1, R58.2, R59.2, S9.6, VR1.1, Y2.1, Y2.4
5V: C3.1, C5.1, IC1.1, IC1.3, IC3.1, IC3.3, J2.18, P-FET2.3, R19.2
5V?: FUSE.1, P-FET2.2
!CS1: IC2.25, IC6.30
!OE: IC2.23, IC6.32
!WE: IC2.118, IC6.5
A0: IC2.4, IC6.20
A1: IC2.3, IC6.19
A2: IC2.2, IC6.18
A3: IC2.1, IC6.17
A4: IC2.144, IC6.16
A5: IC2.143, IC6.15
A6: IC2.142, IC6.14
A7: IC2.141, IC6.13
A8: IC2.120, IC6.3
A9: IC2.121, IC6.2
A10: IC2.24, IC6.31
A11: IC2.122, IC6.1
A12: IC2.135, IC6.12
A13: IC2.119, IC6.4
A14: IC2.134, IC6.11
A15: IC2.116, IC6.7
A16: IC2.129, IC6.10
A17: IC2.128, IC6.9
ADC_IN: IC2.56, R57.2
BLUE: R1.2, R15.2, R16.2, U$1.3
BLUE_1: IC2.87, R1.1
BLUE_2: IC2.88, R15.1
BLUE_3: IC2.90, R16.1
CLK+: IC2.137, R39.2, R41.1
CLK-: IC2.136, R40.2, R41.2
CMD: IC2.33, J3.3, R54.1
CS2: IC2.117, IC6.6
DAT0: IC2.34, J3.7, R55.2
DAT1: IC2.31, J3.8, R59.1
DAT2: IC2.26, J3.1, R45.1
DAT3: IC2.21, J3.2, R58.1
DATA0+: IC2.139, R34.2, R38.1
DATA0-: IC2.138, R35.2, R38.2
DATA1+: IC2.80, R31.2, R33.1
DATA1-: IC2.81, R32.2, R33.2
DATA2+: IC2.78, R28.2, R30.1
DATA2-: IC2.79, R29.2, R30.2
FPGA_CLK: IC2.49, Y2.3
GND: C1.1, C3.2, C4.2, C5.2, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.2, C13.1, C14.1, C15.2, C16.1, C17.1, C18.2, C21.2, C25.2, C26.2, C27.2, IC1.2, IC2.5, IC2.13, IC2.14, IC2.59, IC2.69, IC2.86, IC2.103, IC2.132, IC2.140, IC3.2, IC4.4, IC6.24, J2.2, J2.5, J2.8, J2.11, J2.17, J3.6, JP1.6, LED6.C, P-FET2.1, R36.1, R37.1, R42.2, R43.2, R44.2, S1.2, S2.2, S3.2, S4.2, S5.2, S6.2, S7.2, S8.2, S9.3, S13.2, SJ2.2, U$1.5, U$1.6, U$1.7, U$1.8, U$1.10, U$2.GND1, U$2.GND2, Y2.2
GREEN: R17.2, R18.2, R20.2, U$1.2
GREEN_1: IC2.75, R17.1
GREEN_2: IC2.74, R18.1
GREEN_3: IC2.73, R20.1
H_SYNC: IC2.76, U$1.13
H_SYNC_IN: IC2.62, JP1.5
I/O0: IC2.7, IC6.21
I/O1: IC2.8, IC6.22
I/O2: IC2.9, IC6.23
I/O3: IC2.10, IC6.25
I/O4: IC2.11, IC6.26
I/O5: IC2.12, IC6.27
I/O6: IC2.19, IC6.28
I/O7: IC2.22, IC6.29
ICE_CDONE: IC2.65, JP1.37, R8.1, S9.2
ICE_CREST: IC2.66, JP1.35, R9.1, S9.4
ICE_MISO: IC2.68, IC4.2, JP1.21, S9.7
ICE_MOSI: IC2.67, IC4.5, JP1.19, S9.8
ICE_SCK: IC2.70, IC4.6, JP1.23, R13.1, S9.10
ICE_SS_B: IC2.71, IC4.1, JP1.24, R12.1, S9.5
KEY_0: C13.2, IC2.37, R50.1, R51.2
KEY_0_LED: IC2.28, LED12.A
KEY_1: C6.2, IC2.38, R3.1, R5.2
KEY_1_LED: IC2.29, LED13.A
KEY_2: C11.2, IC2.39, R48.1, R49.2
KEY_3: C1.2, IC2.41, R2.2, R4.1
KEY_4: C10.2, IC2.42, R46.1, R47.2
KEY_5: C7.2, IC2.43, R6.1, R7.2
KEY_6: C9.2, IC2.44, R23.1, R24.2
KEY_7: C8.2, IC2.45, R21.1, R22.2
KEY_8: C14.2, IC2.47, R52.1, R53.2
unnamed: IC4.7, R10.1
unnamed: LED6.A, R19.1
unnamed: IC4.3, R11.1
unnamed: R43.1, U$2.CC2
unnamed: D1.C, IC2.108
unnamed: C22.2, C23.2, IC2.35
unnamed: C22.1, C23.1, IC2.36, R14.1
unnamed: R42.1, U$2.SHIELD1, U$2.SHIELD2, U$2.SHIELD3, U$2.SHIELD4
unnamed: R56.2, VR1.2
unnamed: J2.1, R28.1
unnamed: R44.1, U$2.CC1
unnamed: J2.MH1, J2.MH2, J2.MH3, J2.MH4, SJ2.1
unnamed: C17.2, R56.1, R57.1
unnamed: J2.3, R29.1
unnamed: J2.4, R31.1
unnamed: LED12.C, R36.2
unnamed: LED13.C, R37.2
unnamed: J2.6, R32.1
unnamed: IC2.52, PAD1.1
unnamed: J2.7, R34.1
unnamed: J2.9, R35.1
unnamed: J2.10, R39.1
unnamed: J2.12, R40.1
unnamed: R2.1, S6.1
unnamed: R5.1, S5.1
unnamed: R7.1, S7.1
unnamed: R22.1, S8.1
unnamed: R24.1, S3.1
unnamed: R47.1, S2.1
unnamed: R49.1, S1.1
unnamed: R51.1, S13.1
unnamed: R53.1, S4.1
unnamed: IC2.58, PAD2.1
unnamed: IC2.63, PAD3.1
PRE_FUSE: FUSE.2, U$2.VBUS1, U$2.VBUS2
RED: R25.2, R26.2, R27.2, U$1.1
RED_1: IC2.91, R25.1
RED_2: IC2.95, R26.1
RED_3: IC2.96, R27.1
SD_CLK: IC2.32, J3.5
V_SYNC: IC2.97, U$1.14
V_SYNC_IN: IC2.61, JP1.3

## Code that names these connections

File verilog/SRAM FPGA RPI PERFECTLY RECORDING SINGLE SCREEN SHOT FPGA CLK SOURCE FOR BOTH REC AND PB/constraints.pcf:

set_io FPGA_clk 49

set_io rpi_h_sync 62
set_io rpi_v_sync 61
set_io rpi_color 52

set_io h_sync 76
set_io v_sync 97

set_io rec 47

set_io r_out[0] 91 //for vga
set_io r_out[1] 95 //for vga
set_io r_out[2] 96 //for vga

set_io b_out[0] 87 //for vga
set_io b_out[1] 88 //for vga
set_io b_out[2] 90 //for vga

set_io g_out[0] 75 //for vga
set_io g_out[1] 74 //for vga
set_io g_out[2] 73 //for vga

set_io io[0] 7
set_io io[1] 8
set_io io[2] 9
set_io io[3] 10
set_io io[4] 11
set_io io[5] 12
set_io io[6] 19
set_io io[7] 22

set_io addr[0] 4
set_io addr[1] 3
set_io addr[2] 2
set_io addr[3] 1
set_io addr[4] 144
set_io addr[5] 143
set_io addr[6] 142
set_io addr[7] 141
set_io addr[8] 120
set_io addr[9] 121
set_io addr[10] 24
set_io addr[11] 122
set_io addr[12] 135
set_io addr[13] 119
set_io addr[14] 134
set_io addr[15] 116
set_io addr[16] 129
set_io addr[17] 128

set_io cs 25
set_io oe 23
set_io we 118

## Commit log

2024-01-24 schematic and board
2024-01-26 Finished boards and schematics
2024-07-15 Create delete_me
2024-12-18 works for horizontal and vertical now
2024-12-19 Update passthru.v
    send the one bit from rpi to all the VGA out pins to make it more reliable
2024-12-19 Update constraints.pcf
    added other VGA pins to pcf

Notices in the files:
parts and their libraries:
SparkFun-DiscreteSemi: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
microbuilder: This work is placed in the public domain, and may be freely used for commercial and non-commercial work with the following conditions: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
